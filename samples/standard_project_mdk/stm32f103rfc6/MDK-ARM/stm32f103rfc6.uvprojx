# Keil uVision project stm32f103rfc6.uvprojx, settings and files
target stm32f103rfc6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RF STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80BFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: stm32f103rfc6 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: ../../../../tool/advance_software_protect/Release/advance_software_protect.exe -k 0xfb90ffcb9b62c2e6 -i ./stm32f103rfc6/stm32f103rfc6.bin/ER_IROM1 -r ./stm32f103rfc6/stm32f103rfc6.bin/ER_IROM2
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xG
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0xbf000
  memory RVCT5: ROM 0x20017000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x17000
  scatter file: stm32f103rfc6\stm32f103rfc6.sct
  group Application/MDK-ARM
    ./: startup_stm32f103xg.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_crc.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group sissdk/src
    ../../../../sissdk/aes/: sissdk_aes.c
    ../../../../sissdk/crc/: sissdk_crc16.c sissdk_crc32.c
    ../../../../sissdk/ecdsa/: sissdk_ecdsa.c
    ../../../../sissdk/: sissdk_benchmark.c sissdk_utils.c
  group sissdk/inc
    ../../../../sissdk/aes/: sissdk_aes.h
    ../../../../sissdk/crc/: sissdk_crc.h
    ../../../../sissdk/ecdsa/: sissdk_ecdsa.h
    ../../../../sissdk/: sissdk_benchmark.h sissdk_utils.h
  group mbedtls/src
    ../../../../sissdk/mbedtls_src/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls/inc
    ../../../../sissdk/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h config_bak.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h psa_util.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group AdvanceSoftwareProtect
    ../../../../source/: advance_software_protect_api.h advance_software_protect_config.c advance_software_protect_config.h advance_software_protect_debugger.c advance_software_protect_debugger.h advance_software_protect_encrypt.c advance_software_protect_encrypt.h advance_software_protect_flash.c advance_software_protect_flash.h advance_software_protect_log.h advance_software_protect_objectwatch.c advance_software_protect_objectwatch.h advance_software_protect_objectwatch_list.c advance_software_protect_porting.c advance_software_protect_porting.h advance_software_protect_ramcode.c advance_software_protect_ramcode.h advance_software_protect_samples.c advance_software_protect_signature.c advance_software_protect_signature.h advance_software_protect_type.h
software components: CMSIS:CORE 4.3.0
